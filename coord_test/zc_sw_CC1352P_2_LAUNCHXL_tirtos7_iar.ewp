# IAR project zc_sw_CC1352P_2_LAUNCHXL_tirtos7_iar.ewp, settings and files
configuration default (ARM)
  General.OGChipSelectEditMenu: CC1352P1F3 TexasInstruments CC1352P1F3
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ZCL_READ; ZCL_DISCOVER; ZCL_WRITE; ZCL_BASIC; ZCL_IDENTIFY; ZCL_SCENES; ZCL_GROUPS; ZCL_ON_OFF; ZCL_REPORT_DESTINATION_DEVICE; TIMAC_ROM_PATCH; CUI_DISABLE; MAX_STATUS_LINES=10; ZSTACK_SECURITY; BOARD_DISPLAY_USE_UART; FREQ_2_4G; OSAL_PORT2TIRTOS; OSAL_PORT2TIRTOS_OSALMAP; STACK_LIBRARY; ZDO_API_BASIC; TC_LINKKEY_JOIN; NV_RESTORE; NV_INIT; FEATURE_NON_BEACON_MODE; ZCL_STANDALONE; MAX_DEVICE_TABLE_ENTRIES=50; DEVICE_FAMILY=cc13x0; DeviceFamily_CC13X2; NO_CC1312R1_SUPPORT; TIMAC_ROM_IMAGE_BUILD; NVOCMP_NVPAGES=2; CONFIG_PA_TYPE=APIMAC_HIGH_PA; CC1352P_2; ZDO_COORDINATOR; DISABLE_GREENPOWER_BASIC_PROXY; ZCL_REPORT
  ICCARM.IExtraOptions: --debug; --silent; -e; --aeabi; --thumb; --diag_suppress=Pa050; -fStack/Config/f8wcoord.opts; -ICommon/zcl; -DTIRTOS7_SUPPORT; -DHEAPMGR_CONFIG=0x80; -DHEAPMGR_SIZE=0x00; -I$COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/kernel/tirtos7/packages; -I$COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/posix/iar
  ICCARM.CCIncludePath2: $PROJ_DIR$; Application/StartUp; Application/Services; Application/ui; Application/util; Application/ZStackApi; Common/gp; Common/touchlink; Stack/af; Stack/bdb; $PROJ_DIR/Stack/Config; Stack/gp; Stack/HAL/Crypto; Stack/HAL/Platform; Stack/HAL/RF; Stack/MAC/HighLevel; Stack/MAC/LowLevel; Stack/MAC; Stack/nwk; Stack/osal_port; Stack/ROM; Stack/sec; Stack/sys; Stack/zdo; Stack/zmac; Stack/ZStackTask; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/zstack/mt; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/zstack/osal; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/ti154stack/services/saddr; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/ti154stack/services/sdata; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/ti154stack/hal/crypto; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/ti154stack/hal/platform; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/ti154stack/hal/rf; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/zstack/stack/af; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/zstack/stack/bdb; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/zstack/stack/bdb/touchlinkapp; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/zstack/stack/gp; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/zstack/stack/api; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/zstack/stack/nwk; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/zstack/stack/sec; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/zstack/stack/sys; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/zstack/stack/zcl; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/zstack/stack/zdo; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/zstack/zmac; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/zstack/zmac/f8w; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/zstack/stack/ui; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/common/cui; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/ti154stack; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/ti154stack/fh; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/ti154stack/high_level; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/ti154stack/inc; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/ti154stack/inc/cc13xx; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/ti154stack/low_level/cc13xx; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/ti154stack/tracer; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/ti154stack/rom; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/ti154stack/common/heapmgr; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/ti154stack/common/osal_port; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/ti154stack/common/osal_port/osal_port_posix; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/common/nv; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/zstack/util; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/ti154stack/common/util; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/zstack/config; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/zstack/startup; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/ti154stack/common/api/inc; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/common/time; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/zstack/apps/sw; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/ti154stack/common/boards; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/devices/cc13x2_cc26x2; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/devices/cc13x2_cc26x2/inc; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/devices/cc13x2_cc26x2/driverlib; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/posix/iar
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: $PROJ_DIR$
  postbuild: ielftool --ihex --verbose "$TARGET_BPATH$.out" "$TARGET_BPATH$.hex"
  ILINK.IlinkOutputFile: zc_sw_CC1352P_2_LAUNCHXL_tirtos7_iar.out
  ILINK.IlinkIcfFile: $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/zstack/boards/cc13x2_cc26x2/cc13x2_cc26x2.icf
  ILINK.IlinkExtraOptions: --silent; --redirect; _Printf=_PrintfSmall; --config_def=NVOCMP_NVPAGES=2; -fti_utils_build_linker.cmd.genlibs; -L$COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source; -f$COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/ti154stack/lib/rom/iar/timac_rom_PG2_0_rom_api_linker.icf; -L$COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/kernel/tirtos7/packages; -fti_utils_build_linker.cmd.genlibs; $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/devices/cc13x2_cc26x2/driverlib/bin/iar/driverlib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: SysConfig_Generated_Files.ipcf
  group SysConfig Generated Files
    ./: syscfg_c.rov.xs ti_devices_config.c ti_drivers_config.c ti_drivers_config.h ti_radio_config.c ti_radio_config.h ti_sysbios_config.c ti_sysbios_config.h ti_utils_build_linker.cmd.genlibs ti_zstack_config.c ti_zstack_config.h
  group ZC Sw
    $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/boards/CC1352P_2_LAUNCHXL/: Board.html
    $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/zstack/boards/cc13x2_cc26x2/: cc13x2_cc26x2.icf
    ./: zc_sw.syscfg
  group ZC Sw/Application
    $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/zstack/apps/sw/: zcl_samplesw.c zcl_samplesw.h zcl_samplesw_data.c
  group ZC Sw/Application/Services
    $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/common/nv/: crc.c nvintf.h nvocmp.c nvocmp.h
    $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/ti154stack/services/saddr/: saddr.c saddr.h
    $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/ti154stack/services/sdata/: sdata.h
  group ZC Sw/Application/StartUp
    $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/zstack/startup/: main.c zstackstartup.c zstackstartup.h
  group ZC Sw/Application/util
    $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/ti154stack/common/util/: mac_util.c mac_util.h util_timer.c util_timer.h
    $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/common/time/: utc_clock.c utc_clock.h
  group ZC Sw/Application/ZStackApi
    $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/zstack/stack/api/: zstackapi.c zstackapi.h
  group ZC Sw/Common/gp
    $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/zstack/stack/gp/: gp_bit_fields.c gp_bit_fields.h gp_common.c gp_common.h gp_interface.h gp_proxy.c gp_proxy.h gp_proxy_table.c
  group ZC Sw/Common/touchlink
    $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/zstack/stack/bdb/touchlinkapp/: bdb_tl_commissioning.c bdb_tl_commissioning.h touchlink_initiator_app.c touchlink_initiator_app.h touchlink_target_app.c touchlink_target_app.h
  group ZC Sw/Common/zcl
    $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/zstack/stack/zcl/: zcl.c zcl.h zcl_datatypes.h zcl_general.c zcl_general.h zcl_green_power.c zcl_green_power.h zcl_ha.c zcl_ha.h zcl_port.c zcl_port.h
  group ZC Sw/Excluded_From_Build
    Excluded_From_Build/: README.html
  group ZC Sw/Excluded_From_Build/Common/zcl
    $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/zstack/stack/zcl/: zcl_appliance_control.c zcl_appliance_control.h zcl_appliance_events_alerts.c zcl_appliance_events_alerts.h zcl_appliance_identification.h zcl_appliance_statistics.c zcl_appliance_statistics.h zcl_cc.c zcl_cc.h zcl_cert_data.c zcl_closures.c zcl_closures.h zcl_diagnostic.c zcl_diagnostic.h zcl_electrical_measurement.c zcl_electrical_measurement.h zcl_hvac.c zcl_hvac.h zcl_lighting.c zcl_lighting.h zcl_ll.c zcl_ll.h zcl_ms.c zcl_ms.h zcl_ota.c zcl_ota.h zcl_partition.c zcl_partition.h zcl_pi.c zcl_pi.h zcl_poll_control.c zcl_poll_control.h zcl_power_profile.c zcl_power_profile.h zcl_retail.c zcl_retail.h zcl_se.c zcl_se.h zcl_ss.c zcl_ss.h zcl_telecommunication.c zcl_telecommunication.h
  group ZC Sw/Stack/af
    $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/zstack/stack/af/: af.c af.h
  group ZC Sw/Stack/bdb
    $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/zstack/stack/bdb/: bdb.c bdb.h bdb_finding_and_binding.c bdb_interface.h bdb_reporting.c bdb_reporting.h bdb_touchlink.c bdb_touchlink.h bdb_touchlink_initiator.c bdb_touchlink_initiator.h bdb_touchlink_target.c bdb_touchlink_target.h
  group ZC Sw/Stack/Config
    Stack/Config/: f8wcoord.opts
    $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/ti154stack/common/boards/: mac_user_config.c mac_user_config.h
  group ZC Sw/Stack/gp
    $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/zstack/stack/gp/: cgp_stub.h dgp_stub.h
  group ZC Sw/Stack/HAL/Crypto
    $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/ti154stack/hal/crypto/: crypto_mac_api.h
  group ZC Sw/Stack/HAL/Platform
    $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/ti154stack/hal/platform/: hal_defs.h hal_mcu.h hal_types.h
  group ZC Sw/Stack/HAL/RF
    $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/ti154stack/hal/rf/: rf_mac_api.h
  group ZC Sw/Stack/MAC
    $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/ti154stack/inc/: mac_api.h
  group ZC Sw/Stack/MAC/Debug
    $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/ti154stack/tracer/: dbg.c dbg.h
  group ZC Sw/Stack/MAC/HighLevel
    $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/ti154stack/high_level/: mac_cfg.c mac_high_level.h
  group ZC Sw/Stack/MAC/LowLevel
    $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/ti154stack/low_level/cc13xx/: mac_activity.c mac_activity.h mac_assert.h mac_rx.h mac_settings.c mac_settings.h mac_tx.h
  group ZC Sw/Stack/nwk
    $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/zstack/stack/nwk/: addr_mgr.h aps.h aps_frag.h aps_groups.h aps_mede.h aps_util.h assoc_list.h binding_table.c binding_table.h nl_mede.h nwk.h nwk_bufs.h nwk_globals.c nwk_globals.h nwk_util.h reflecttrack.h rtg.h stub_aps.c stub_aps.h
  group ZC Sw/Stack/osal_port
    $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/zstack/osal/: osal_nv.c osal_nv.h
    $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/ti154stack/common/osal_port/osal_port_posix/: osal_port.c osal_port_timers.c
    $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/ti154stack/common/osal_port/: osal_port.h osal_port_timers.h
  group ZC Sw/Stack/ROM
    $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/ti154stack/rom/: fh_map_direct.h fh_rom_init.c fh_rom_jt.h hmac_map_direct.h hmac_rom_init.c hmac_rom_jt.h icall_osal_map_direct.h icall_osal_rom_init.c icall_osal_rom_jt.h lmac_map_direct.h lmac_rom_init.c lmac_rom_jt.h rom_init_154.c rom_jt_154.h rom_jt_def_154.h
  group ZC Sw/Stack/sec
    $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/zstack/stack/sec/: eccapi.h ssp.h ssp_hash.h
  group ZC Sw/Stack/sys
    $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/zstack/stack/sys/: comdef.h zcomdef.h zdiags.c zdiags.h zglobals.c zglobals.h
  group ZC Sw/Stack/zdo
    $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/zstack/stack/zdo/: zd_app.c zd_app.h zd_config.c zd_config.h zd_nwk_mgr.c zd_nwk_mgr.h zd_object.c zd_object.h zd_profile.c zd_profile.h zd_sec_mgr.c zd_sec_mgr.h
  group ZC Sw/Stack/zmac
    $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/zstack/zmac/f8w/: zmac.c zmac_cb.c zmac_internal.h
    $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/zstack/zmac/: zmac.h
  group ZC Sw/Stack/ZStackTask
    $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/zstack/stack/api/: zstack.h zstackconfig.h zstackmsg.h zstacktask.c zstacktask.h zsversion.h

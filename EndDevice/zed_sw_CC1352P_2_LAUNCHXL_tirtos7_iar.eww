<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\zed_sw_CC1352P_2_LAUNCHXL_tirtos7_iar.ewp</path>
    </project>
    <batchBuild />
</workspace>
